FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-show-maximized-window.patch"

LIC_FILES_CHKSUM = "file://main.cpp;md5=e7ee937bf4d20544682aaa7955dc2ee4"
