# This revision corresponds to the tag "v2017.01"
# We use the revision in order to avoid having to fetch it from the
# repo during parse
SRC_URI = "git://git.denx.de/u-boot.git"
SRCREV = "7df4ff2c2689a6d3c16eb0c3cce098fcac622b0c"
